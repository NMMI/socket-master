# Keil uVision project hand_firmware_micro_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: hand_firmware_micro_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h MOTOR_1A.c MOTOR_1A.h MOTOR_1A_aliases.h MOTOR_EN.c MOTOR_EN.h MOTOR_EN_aliases.h MOTOR_2A.c MOTOR_2A.h MOTOR_2A_aliases.h CLOCK_UART.c CLOCK_UART.h ISR_RS485_RX.c ISR_RS485_RX.h RS_485_EN.c RS_485_EN.h RS_485_EN_aliases.h PWM_MOTORS.c PWM_MOTORS.h PWM_MOTORS_PM.c CLOCK_PWM.c CLOCK_PWM.h Signal_1_C.c Signal_1_C.h Signal_1_C_aliases.h PACER_TIMER.c PACER_TIMER.h PACER_TIMER_PM.c UART_RS485.c UART_RS485.h UART_RS485_PM.c UART_RS485_INT.c UART_RS485_BOOT.c MOTOR_1B.c MOTOR_1B.h MOTOR_1B_aliases.h MOTOR_2B.c MOTOR_2B.h MOTOR_2B_aliases.h MOTOR_DIR.h MOTOR_DIR.c MOTOR_DIR_PM.c COUNTER_ENC.c COUNTER_ENC.h COUNTER_ENC_PM.c SHIFTREG_ENC_3.c SHIFTREG_ENC_3.h SHIFTREG_ENC_3_PM.c CLOCK_ENCODERS.c CLOCK_ENCODERS.h SHIFTREG_ENC_2.c SHIFTREG_ENC_2.h SHIFTREG_ENC_2_PM.c EEPROM.c EEPROM.h USB_VDD.c USB_VDD.h USB_VDD_aliases.h FTDI_ENABLE.c FTDI_ENABLE.h FTDI_ENABLE_aliases.h Signal_1_B.c Signal_1_B.h Signal_1_B_aliases.h ADC.c ADC.h ADC_PM.c ADC_INT.c BOARD_LED.c BOARD_LED.h BOARD_LED_aliases.h Signal_1_A.c Signal_1_A.h Signal_1_A_aliases.h RS485_CTS.h RS485_CTS.c RS485_CTS_PM.c MOTOR_ON_OFF.h MOTOR_ON_OFF.c MOTOR_ON_OFF_PM.c FTDI_ENABLE_REG.h FTDI_ENABLE_REG.c FTDI_ENABLE_REG_PM.c CURRENT_SENSE_1.c CURRENT_SENSE_1.h CURRENT_SENSE_1_aliases.h RESET_FF.h RESET_FF.c RESET_FF_PM.c FF_STATUS.c FF_STATUS.h MY_TIMER.c MY_TIMER.h MY_TIMER_PM.c timer_clock.c timer_clock.h VOLTAGE_SENSE.c VOLTAGE_SENSE.h VOLTAGE_SENSE_aliases.h SHIFTREG_ENC_1.c SHIFTREG_ENC_1.h SHIFTREG_ENC_1_PM.c RESET_COUNTERS.h RESET_COUNTERS.c RESET_COUNTERS_PM.c ADC_STATUS.c ADC_STATUS.h DMA_dma.c DMA_dma.h ADC_SOC.h ADC_SOC.c ADC_SOC_PM.c WATCHDOG_CLK.c WATCHDOG_CLK.h ISR_WATCHDOG.c ISR_WATCHDOG.h WATCHDOG_COUNTER.c WATCHDOG_COUNTER.h WATCHDOG_COUNTER_PM.c WATCHDOG_ENABLER.h WATCHDOG_ENABLER.c WATCHDOG_ENABLER_PM.c WATCHDOG_REFRESH.h WATCHDOG_REFRESH.c WATCHDOG_REFRESH_PM.c ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h LED_BLINK.c LED_BLINK.h LED_BLINK_PM.c LED_CTRL.h LED_CTRL.c LED_CTRL_PM.c LED_BLINK_EN.h LED_BLINK_EN.c LED_BLINK_EN_PM.c CLOCK_PWM_1.c CLOCK_PWM_1.h INPUT_2.c INPUT_2.h INPUT_2_aliases.h INPUT_1.c INPUT_1.h INPUT_1_aliases.h
target Release (MCS-51)
  device: CY8C3246PVI-147 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(50000000) MODDP2"
  output: hand_firmware_micro_PSoC3lib (library)
  c flags: Optimize=8 SizeSpeed=1
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
